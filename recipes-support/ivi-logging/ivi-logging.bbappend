FILESEXTRAPATHS_append := ":${THISDIR}/${PN}"

SRC_URI += "file://0001-Fix-streaming-operator-for-unsigned-long-ints-on-32-.patch"
